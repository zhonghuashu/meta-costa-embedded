FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://vsftpd.conf"
